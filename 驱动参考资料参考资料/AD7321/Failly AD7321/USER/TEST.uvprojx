# Keil uVision project TEST.uvprojx, settings and files
target TEST (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TEST +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\JDQ;..\HARDWARE\SPI;..\HARDWARE\SPIAD;..\Free Modbus\ascii;..\Free Modbus\functions;..\Free Modbus\include;..\Free Modbus\rtu;..\Free Modbus\tcp;..\Modbus Port;..\HARDWARE\IIC
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/JDQ/: JDQ.c
    ../HARDWARE/SPI/: spi538.c
    ../HARDWARE/SPIAD/: spiad.c
    ../HARDWARE/IIC/: iic.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c
  group FREE MB
    ../Free Modbus/ascii/: mbascii.c
    ../Free Modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../Free Modbus/rtu/: mbcrc.c mbrtu.c
    ../Free Modbus/tcp/: mbtcp.c
    ../Free Modbus/: mb.c
  group MBPort
    ../Modbus Port/: portevent.c portserial.c porttimer.c
